# Keil uVision project SDIO_test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1901VC1 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SDIO_test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src_brd;.\FF13b;..\SDIO_SDCard_FileSys
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./: main.c
    ./src_brd/: brdLed.c brdClock.c brdBtn.c brdUtils.c brdSDIO.c brdSysTimer.c brdSD_Card.c
  group FileFS
    ./FF13b/: diskio.c ff.c ffsystem.c ffunicode.c test_funcIO.c
    ./: test_funcIO.h
software components: Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:SDIO 1.5
